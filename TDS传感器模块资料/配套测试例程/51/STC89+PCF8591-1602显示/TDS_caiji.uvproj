# Keil uVision project TDS_caiji.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PH_caiji +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group Source Group 1
    ./: STARTUP.A51
    ./user/: Lcd1602.c PCF8591.c PH_caiji.c I2C.c
